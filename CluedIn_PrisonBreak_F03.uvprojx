# Keil uVision project CluedIn_PrisonBreak_F03.uvprojx, settings and files
target LightSequence (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F030C6 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IRAM(0x20000000,0x1000) IROM(0x08000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: LightSequence
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Source;.\RTE\Device\STM32F030C6
  asm include: .\RTE\Device\STM32F030C6
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Main
    ./Source/: light_sequence.c valves.c light_picture.c ddr_mat.c control_room_panel.c keypad.c the_control_room.c keypad_guard_keys.c
  group Support
    ./Source/: utils.c
target Valves (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F030C6 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: as above
  output: LightSequence
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Source;.\RTE\Device\STM32F030C6
  asm include: .\RTE\Device\STM32F030C6
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
target LightPicture (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F030C6 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: as above
  output: LightSequence +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Source;.\RTE\Device\STM32F030C6
  asm include: .\RTE\Device\STM32F030C6
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
target DDRMat (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F030C6 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: as above
  output: LightSequence
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Source;.\RTE\Device\STM32F030C6
  asm include: .\RTE\Device\STM32F030C6
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
target ControlRoomPanel (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F030C6 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: as above
  output: CluedIn_PrisonBreak
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Source;.\RTE\Device\STM32F030C6
  asm include: .\RTE\Device\STM32F030C6
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
target Keypad (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F030C6 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: as above
  output: LightSequence
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Source;.\RTE\Device\STM32F030C6
  asm include: .\RTE\Device\STM32F030C6
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
target TheControlRoom (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F030C6 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: as above
  output: LightSequence
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Source;.\RTE\Device\STM32F030C6
  asm include: .\RTE\Device\STM32F030C6
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
target KeypadGuardKeys (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F030C6 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: as above
  output: LightSequence +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Source;.\RTE\Device\STM32F030C6
  asm include: .\RTE\Device\STM32F030C6
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
software components: CMSIS:CORE 5.0.0, Device:Startup 2.2.3
